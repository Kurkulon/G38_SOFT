# Keil uVision project G38LPC824.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: NXP.LPC824_DFP.10.0.3
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: G38LPC824
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
